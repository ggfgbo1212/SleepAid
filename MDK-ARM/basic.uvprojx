# Keil uVision project basic.uvprojx, settings and files
target basic (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: basic +hex
  BeforeMake: $P\fix_bom.bat
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=bin/@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../1_Appcations;../2_Devices;../2_Devices/at24cxx;../3_ModuleDrivers;../4_include;../5_libs;../2_Devices/w25q;../2_Devices/st7789;../2_Devices/touch;../6_Middlewares/cjon;../6_Middlewares/MD5;../2_Devices/wifi;../6_Middlewares/paho.mqtt.embedded-c-master/MQTTPacket/src;../6_Middlewares/paho.mqtt.embedded-c-master/MQTTClient-C/src;../6_Middlewares/paho.mqtt.embedded-c-master/MQTTClient-C/src/FreeRTOS;../6_Middlewares/lvgl/action;../6_Middlewares/lvgl/tickscreen;../6_Middlewares/lvgl/SleepAid_UI/lvgl;../6_Middlewares/lvgl/SleepAid_UI/custom;../6_Middlewares/lvgl/SleepAid_UI/generated;../6_Middlewares/lvgl/SleepAid_UI/generated/guider_fonts;../6_Middlewares/lvgl/SleepAid_UI;..\6_Middlewares\MD5
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group 1_Applications
    ../1_Appcations/: gpio_test.c aiot_mqtt_sign.c mqtt_base.c mqtt_ota_ali.c iap.c
  group 2_Devices
    ../2_Devices/: dev_gpio.c dev_uart.c dev_iic.c dev_spi.c
  group 2_Module_Devices
    ../2_Devices/w25q/: dev_w25q64.c
    ../2_Devices/at24cxx/: dev_at24c02.c
    ../2_Devices/wifi/: dev_wifi.c
    ../2_Devices/st7789/: dev_st7789.c
    ../2_Devices/touch/: xpt2046.c
  group 3_ModuleDrivers
    ../3_ModuleDrivers/: drv_gpio.c drv_uart.c drv_iic.c drv_spi.c drv_flash.c
  group 4_include
    ../4_include/: errno.h
  group 5_libs
    ../5_libs/: printf.c ring_buffer.c
  group 06_Middleware/MQTT
    ../6_Middlewares/paho.mqtt.embedded-c-master/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../6_Middlewares/paho.mqtt.embedded-c-master/MQTTClient-C/src/: MQTTClient.c
    ../6_Middlewares/paho.mqtt.embedded-c-master/MQTTClient-C/src/FreeRTOS/: MQTTFreeRTOS.c
  group 06_Middleware/Cjon
    ../6_Middlewares/cjon/: cJSON.c
  group 6_Middlewares/md5
    ../6_Middlewares/MD5/: md5.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c i2c.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group 6_Middlewares/lvgl/core
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group 6_Middlewares/lvgl/draw
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group 6_Middlewares/lvgl/extra
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/extra/: lv_extra.c
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/extra/widgets/led/: lv_led.c
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/extra/themes/default/: lv_theme_default.c
  group 6_Middlewares/lvgl/font
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c
  group 6_Middlewares/lvgl/hal
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group 6_Middlewares/lvgl/misc
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_utils.c
  group 6_Middlewares/lvgl/widgets
    ../6_Middlewares/lvgl/SleepAid_UI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group 6_Middlewares/lvgl/custom
    ../6_Middlewares/lvgl/SleepAid_UI/custom/: custom.c
  group 6_Middlewares/lvgl/generate
    ../6_Middlewares/lvgl/SleepAid_UI/generated/: events_init.c gui_guider.c setup_scr_SettingsPage4CheckUpdate1.c setup_scr_SettingsPage4CheckUpdate2.c setup_scr_SettingsPage4CheckUpdate3.c setup_scr_SettingsPage4Info.c setup_scr_SettingsPage4UpdateCplt.c setup_scr_SettingsPage4UpdateError.c setup_scr_SettingsPage4Updating.c widgets_init.c
    ../6_Middlewares/lvgl/SleepAid_UI/generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_simsun_12.c lv_font_simsun_16.c lv_font_simsun_25.c
    ../6_Middlewares/lvgl/SleepAid_UI/generated/images/: _trademark_alpha_34x34.c _download_alpha_185x135.c _downloadx_alpha_185x135.c
  group 6_Middlewares/lvgl/conf
    ../6_Middlewares/lvgl/SleepAid_UI/: lv_conf.h
  group 6_Middlewares/lvgl/port
    ../6_Middlewares/lvgl/SleepAid_UI/: lv_port_disp_template.c lv_port_indev_template.c
  group 6_Middlewares/lvgl/action
    ../6_Middlewares/lvgl/action/: lvgl_action.c
  group 6_Middlewares/lvgl/tickscreen
    ../6_Middlewares/lvgl/tickscreen/: tickscreen.c
software components: CMSIS:CORE 4.3.0
